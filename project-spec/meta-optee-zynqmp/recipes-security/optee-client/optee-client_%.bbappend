COMPATIBLE_MACHINE = "zynqmp-generic"
